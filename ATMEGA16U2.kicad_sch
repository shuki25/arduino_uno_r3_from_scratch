File: ATMEGA16U2.kicad_sch (KiCad schematic)
At the start: 16 parts, among them U4 ATMEGA16U2-MU, X1 FOXSLF/160-20

Commit message: add packages
Parts:
- C10, C7, C8, C9: footprint ~ -> Capacitor_SMD:C_0603_1608Metric
- D4: footprint ~ -> Diode_SMD:D_SMA
- D5, D6: footprint ~ -> LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
- ICSP1: footprint ~ -> Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical
- JP2: footprint ~ -> Connector_PinHeader_2.54mm:PinHeader_2x02_P2.54mm_Vertical
- R10, R11, R7, R8, R9: footprint ~ -> Resistor_SMD:R_0603_1608Metric
- U4: footprint (none) -> Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm
- X1: footprint ~ -> Crystal:Crystal_SMD_3215-2Pin_3.2x1.5mm
Changed lines of the file:
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@@
       (effects (font (size 1.524 1.524)))
     )
-    (property "Footprint" "" (at 144.78 63.5 0)
-      (effects (font (size 1.524 1.524)))
+    (property "Footprint" "Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm" (at 144.78 63.5 0)
+      (effects (font (size 1.524 1.524)) hide)
     )
     (property "Datasheet" "http://www.atmel.com/Images/doc7799.pdf" (at 144.78 63.5 0)
@@
       (effects (font (size 1.524 1.524)))
     )
-    (property "Footprint" "~" (at 100.33 71.12 0)
-      (effects (font (size 1.524 1.524)))
+    (property "Footprint" "Crystal:Crystal_SMD_3215-2Pin_3.2x1.5mm" (at 100.33 71.12 0)
+      (effects (font (size 1.524 1.524)) hide)
     )
     (property "Datasheet" "http://www.foxonline.com/pdfs/hc49slf.pdf" (at 100.33 71.12 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 108.712 71.12 90)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 108.712 71.12 90)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://www.vishay.com/docs/20035/dcrcwe3.pdf" (at 110.49 71.12 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 91.44 57.4548 0)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (at 91.44 57.4548 0)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://www.kemet.com/docfinder?Partnumber=C0805C200G5GACTU" (at 87.63 58.42 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 71.12 26.67 0)
-      (effects (font (size 1.524 1.524)))
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" (at 71.12 26.67 0)
+      (effects (font (size 1.524 1.524)) hide)
     )
     (property "Datasheet" "http://cdn.harwin.com/pdfs/M20-998.pdf" (at 71.12 26.67 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 110.49 35.56 0)
-      (effects (font (size 1.524 1.524)))
+    (property "Footprint" "Diode_SMD:D_SMA" (at 110.49 35.56 0)
+      (effects (font (size 1.524 1.524)) hide)
     )
     (property "Datasheet" "http://www.diodes.com/_files/datasheets/ds30086.pdf" (at 110.49 35.56 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 200.66 45.72 0)
-      (effects (font (size 1.524 1.524)))
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_2x02_P2.54mm_Vertical" (at 200.66 45.72 0)
+      (effects (font (size 1.524 1.524)) hide)
     )
     (property "Datasheet" "~" (at 200.66 45.72 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 91.44 82.8548 0)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (at 91.44 82.8548 0)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://www.kemet.com/docfinder?Partnumber=C0805C200G5GACTU" (at 87.63 83.82 0)
@@
       (effects (font (size 1.016 1.016)) (justify left))
     )
-    (property "Footprint" "~" (at 88.5952 107.95 0)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (at 88.5952 107.95 0)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://images.ihscontent.net/vipimages/VipMasterIC/IC/KEME/KEMES10043/KEMES10043-1.pdf" (at 87.63 104.14 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 106.68 126.0348 0)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Capacitor_SMD:C_0603_1608Metric" (at 106.68 126.0348 0)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://www.kemet.com/docfinder?Partnumber=C0805C105K8RACAUTO" (at 102.87 127 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 106.172 142.24 90)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 106.172 142.24 90)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://industrial.panasonic.com/www-cgi/jvcr13pz.cgi?E+PZ+3+AOA0001+ERJ6GEY0R00V+7+WW" (at 107.95 142.24 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 102.108 35.56 90)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 102.108 35.56 90)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://images.ihscontent.net/vipimages/VipMasterIC/IC/VISH/VISHS75859/VISHS75859-1.pdf" (at 100.33 35.56 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 205.74 133.858 90)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 205.74 133.858 90)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://www.yageo.com/pdf/Pu-RC0805_51_PbFree_L_2.pdf" (at 205.74 132.08 0)
@@
       (effects (font (size 1.016 1.016)))
     )
-    (property "Footprint" "~" (at 205.74 138.938 90)
-      (effects (font (size 0.762 0.762)))
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 205.74 138.938 90)
+      (effects (font (size 0.762 0.762)) hide)
     )
     (property "Datasheet" "http://www.yageo.com/pdf/Pu-RC0805_51_PbFree_L_2.pdf" (at 205.74 137.16 0)
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "~" (at 189.23 132.08 0)
-      (effects (font (size 1.524 1.524)))
+    (property "Footprint" "LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder" (at 189.23 132.08 0)
+      (effects (font (size 1.524 1.524)) hide)
     )
     (property "Datasheet" "http://www.osram-os.com/Graphics/XPic9/00078860_0.pdf" (at 189.23 132.08 0)
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "~" (at 189.23 137.16 0)
-      (effects (font (size 1.524 1.524)))
+    (property "Footprint" "LED_SMD:LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder" (at 189.23 137.16 0)
+      (effects (font (size 1.524 1.524)) hide)
     )
     (property "Datasheet" "http://www.osram-os.com/Graphics/XPic9/00078860_0.pdf" (at 189.23 137.16 0)

Commit message: change power symbols and Arduino header
Connections:
- net 5V_LDO renamed +5V
- net USBVCC renamed VCC
Changed lines of the file:
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@@
     )
   )
-  (hierarchical_label "SERIAL_Rx" (shape input) (at 250.19 142.24 0)
+  (hierarchical_label "SERIAL_Rx" (shape input) (at 250.19 142.24 0) (fields_autoplaced)
     (effects (font (size 1.016 1.016)) (justify left))
   )
-  (hierarchical_label "SERIAL_Tx" (shape input) (at 250.19 147.32 0)
+  (hierarchical_label "SERIAL_Tx" (shape input) (at 250.19 147.32 0) (fields_autoplaced)
     (effects (font (size 1.016 1.016)) (justify left))
   )
-  (hierarchical_label "USB_RD+" (shape input) (at 39.37 121.92 180)
+  (hierarchical_label "USB_RD+" (shape input) (at 39.37 121.92 180) (fields_autoplaced)
     (effects (font (size 1.524 1.524)) (justify right))
   )
-  (hierarchical_label "DTR" (shape input) (at 250.19 121.92 0)
+  (hierarchical_label "DTR" (shape input) (at 250.19 121.92 0) (fields_autoplaced)
     (effects (font (size 1.016 1.016)) (justify left))
   )
-  (hierarchical_label "USB_GND" (shape input) (at 39.37 132.08 180)
+  (hierarchical_label "USB_GND" (shape input) (at 39.37 132.08 180) (fields_autoplaced)
     (effects (font (size 1.524 1.524)) (justify right))
   )
-  (hierarchical_label "USB_RD-" (shape input) (at 39.37 116.84 180)
+  (hierarchical_label "USB_RD-" (shape input) (at 39.37 116.84 180) (fields_autoplaced)
     (effects (font (size 1.524 1.524)) (justify right))
   )
@@
     )
   )
-  (symbol (lib_id "Arduino_Uno_R3_From_Scratch:5V_LDO") (at 218.44 127 0) (unit 1)
+  (symbol (lib_id "power:+5V") (at 218.44 127 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
     (property "Reference" "#PWR031" (at 218.44 124.714 0)
@@
     )
     (property "Footprint" "~" (at 218.44 127 0)
-      (effects (font (size 1.524 1.524)))
+      (effects (font (size 1.27 1.27)) hide)
     )
     (property "Datasheet" "~" (at 218.44 127 0)
-      (effects (font (size 1.524 1.524)))
+      (effects (font (size 1.27 1.27)) hide)
     )
     (pin "1")
@@
     )
   )
-  (symbol (lib_id "Arduino_Uno_R3_From_Scratch:USBVCC") (at 105.41 106.68 0) (unit 1)
+  (symbol (lib_id "power:VCC") (at 105.41 106.68 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
     (property "Reference" "#PWR032" (at 105.41 104.394 0)
@@
     )
     (property "Footprint" "~" (at 105.41 106.68 0)
-      (effects (font (size 1.524 1.524)))
+      (effects (font (size 1.27 1.27)) hide)
     )
     (property "Datasheet" "~" (at 105.41 106.68 0)
-      (effects (font (size 1.524 1.524)))
+      (effects (font (size 1.27 1.27)) hide)
     )
     (pin "1")
@@
     )
   )
-  (symbol (lib_id "Arduino_Uno_R3_From_Scratch:5V_LDO") (at 87.63 93.98 0) (unit 1)
+  (symbol (lib_id "power:+5V") (at 87.63 93.98 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
     (property "Reference" "#PWR033" (at 87.63 91.694 0)
@@
     )
     (property "Footprint" "~" (at 87.63 93.98 0)
-      (effects (font (size 1.524 1.524)))
+      (effects (font (size 1.27 1.27)) hide)
     )
     (property "Datasheet" "~" (at 87.63 93.98 0)
-      (effects (font (size 1.524 1.524)))
+      (effects (font (size 1.27 1.27)) hide)
     )
     (pin "1")
@@
     )
   )
-  (symbol (lib_id "Arduino_Uno_R3_From_Scratch:5V_LDO") (at 100.33 20.32 0) (unit 1)
+  (symbol (lib_id "power:+5V") (at 100.33 20.32 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
     (property "Reference" "#PWR034" (at 100.33 18.034 0)
@@
     )
     (property "Footprint" "~" (at 100.33 20.32 0)
-      (effects (font (size 1.524 1.524)))
+      (effects (font (size 1.27 1.27)) hide)
     )
     (property "Datasheet" "~" (at 100.33 20.32 0)
-      (effects (font (size 1.524 1.524)))
-    )
-    (pin "1")
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
