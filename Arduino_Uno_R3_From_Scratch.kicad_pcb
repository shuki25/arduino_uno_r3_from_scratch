# Repository shuki25/arduino_uno_r3_from_scratch

## KiCad design Arduino_Uno_R3_From_Scratch.kicad_pcb

Parts:
C1, C2: 47uF; C_Elec_3x5.4; MPN MAL215371479E3
C3: 0.1 uF; C_0603_1608Metric; MPN C0805C104K1RACAUTO
D1: DIODE; D_SMA; MPN MRA4007T3G
D2: LED; LED_0603_1608Metric; MPN LG R971-KN-1
J2: Barrel_Jack_Switch; BarrelJack_Wuerth_6941xx301002
R1: 510; R_0603_1608Metric; MPN RC0805FR-07510RL
U1: LD1117S50TR; SOT-223; MPN LD1117S50TR

Connections:
+5V: C2.1, C3.1, R1.2, U1.2 (Vout); also elsewhere on the board
GND: C1.2, C2.2, C3.2, D2.1 (K), J2.2, J2.3, U1.1 (GND); also elsewhere on the board
unnamed: D1.2 (A), J2.1
unnamed: D2.2 (A), R1.1
VDD: C1.1, D1.1 (K), U1.3 (Vin); also elsewhere on the board

Notes on the sheet:
Power Flags for ERC
Barrel Plug must be 2.1mm ID x 5.5mm OD

Parts:
C4: 0.1 uF; C_0603_1608Metric; MPN C0805C104K1RACAUTO
C5: 1uF; C_0603_1608Metric; MPN C0805C105K8RACAUTO
C6: 2.2uF; C_0603_1608Metric; MPN C2012X7R1C225K125AB
Q1: FDN340P; SOT-23; MPN FDN340P
R2, R3: 10K; R_0603_1608Metric; MPN CRCW080510K0JNEA
U2: LMV358IDGKR; HVSSOP-8-1EP_3x3mm_P0.65mm_EP1.57x1.89mm; MPN LMV358IDGKR
U3: LP2985-33DBVR; SOT-23-5; MPN LP2985-33DBVR

Connections:
+3V3: C6.1, U2.2 (-), U3.5 (VOUT); also elsewhere on the board
+5V: C4.2, C5.1, Q1.2 (S), U2.8 (V+), U3.1 (VIN), U3.3 (ON/~OFF); also elsewhere on the board
GND: C4.1, C5.2, C6.2, R3.1, U2.4 (V-), U3.2 (GND); also elsewhere on the board
unnamed: Q1.1 (G), U2.1
unnamed: R2.1, R3.2, U2.3 (+)
VCC: Q1.3 (D); also elsewhere on the board
VDD: R2.2; also elsewhere on the board

Notes on the sheet:
USBVCC / VIN Comparator

Parts:
D3: LED; LED_0603_1608Metric; MPN LG R971-KN-1
R4: 510; R_0603_1608Metric; MPN RC0805FR-07510RL
U2: LMV358IDGKR; HVSSOP-8-1EP_3x3mm_P0.65mm_EP1.57x1.89mm; MPN LMV358IDGKR

Connections:
/ATMEGA328P/ARD_DIG13/SPI_SCK: U2.5 (+); also elsewhere on the board
GND: D3.1 (K); also elsewhere on the board
unnamed: D3.2 (A), R4.2
unnamed: R4.1, U2.6 (-), U2.7

Notes on the sheet:
Power Pins for U2 LMV358IDGKR (Component C) are located with bypass capacitors in the Voltage Management schematic.
SCK / PIN13 LED Buffer

Parts:
F1: 500mA; R_0805_2012Metric; MPN MF-MSMF050-2
FB1: BLM21PG221SN1D; L_0805_2012Metric; MPN BLM21PG221SN1D
J1: USB_TYPE_B; USB_Micro-B_Molex-105017-0001
R5, R6: 22R; R_0603_1608Metric; MPN RC0805JR-0722RL
VR1, VR2: CG0603MLC-05E; R_0603_1608Metric; MPN CG0603MLC-05E

Connections:
/ATMEGA16U2/USB_GND: FB1.2, J1.5 (GND); also elsewhere on the board
/ATMEGA16U2/USB_RD+: R5.2; also elsewhere on the board
/ATMEGA16U2/USB_RD-: R6.2; also elsewhere on the board
unnamed: J1.3 (D+), R5.1, VR2.1
unnamed: J1.2 (D-), R6.1, VR1.1
unnamed: FB1.1, J1.6 (Shield), VR1.2, VR2.2
unnamed: F1.1, J1.1 (VBUS)
VCC: F1.2; also elsewhere on the board

Notes on the sheet:
PIN 4 GND will throw an ERC error due to the pin being separated from GND by a 0R resistor in the ATMEGA16U2 schematic. This error is accepted.
Verify serial resistor layout guidelines ATMEGA16U2 datasheet page 189

Parts:
C7, C8: 20pF; C_0603_1608Metric; MPN C0805C200G5GACTU
C9: 0.1 uF; C_0603_1608Metric; MPN C0805C104K1RACAUTO
C10: 1uF; C_0603_1608Metric; MPN C0805C105K8RACAUTO
D4: 1N4148W-7-F; D_SMA; MPN 1N4148W-7-F
D5, D6: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN LG R971-KN-1
ICSP1: M20-9980346; PinHeader_2x03_P2.54mm_Vertical; MPN M20-9980346
JP2: NO_POP; PinHeader_2x02_P2.54mm_Vertical; MPN FOOTPRINT ONLY; not fitted
R7: 10K; R_0603_1608Metric; MPN CRCW080510K0JNEA
R8: 0; R_0603_1608Metric; MPN ERJ-6GEY0R00V
R9: 1M; R_0603_1608Metric; MPN CRCW08051M00FKEA
R10, R11: 510; R_0603_1608Metric; MPN RC0805FR-07510RL
U4: ATMEGA16U2-MU; QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm; MPN ATMEGA16U2-MU
X1: FOXSLF/160-20; Crystal_SMD_3215-2Pin_3.2x1.5mm; MPN FOXSLF/160-20

Connections:
+5V: C9.1, D4.2 (A), ICSP1.2, R7.2, R10.2, R11.2, U4.4 (VCC), U4.32 (AVCC); also elsewhere on the board
/ATMEGA16U2/DTR: U4.13 ((CTS/HWB/TO/INT7)PD7); also elsewhere on the board
/ATMEGA16U2/SERIAL_Rx: U4.9 ((TXD1/INT3)PD3); also elsewhere on the board
/ATMEGA16U2/SERIAL_Tx: U4.8 ((RXD1/AIN1/INT2)PD2); also elsewhere on the board
/ATMEGA16U2/USB_GND: C10.1, R8.1, U4.28 (UGND); also elsewhere on the board
/ATMEGA16U2/USB_RD+: U4.29 (D+); also elsewhere on the board
/ATMEGA16U2/USB_RD-: U4.30 (D-); also elsewhere on the board
GND: C7.1, C8.1, C9.2, ICSP1.6, R8.2, U4.3 (GND), U4.33 (PAD); also elsewhere on the board
ICSP_MISO: ICSP1.1, U4.17 ((PD0/MISO/PCINT3)PB3)
ICSP_MOSI: ICSP1.4, U4.16 ((PDI/MOSI/PCINT2)PB2)
ICSP_SCK: ICSP1.3, U4.15 ((SCLK/PCINT1)PB1)
unnamed: D4.1 (K), ICSP1.5, R7.1, U4.24 (RESET(PC1/DW))
unnamed: D5.2 (A), R10.1
unnamed: D5.1 (K), U4.11 ((XCK/AIN4/PCINT12)PD5)
unnamed: D6.2 (A), R11.1
unnamed: D6.1 (K), U4.10 ((INT5/AIN3)PD4)
unnamed: JP2.1, U4.18 ((T1/PCINT4)PB4)
unnamed: JP2.2, U4.21 ((PCINT7/OC0A/OC1C)PB7)
unnamed: JP2.3, U4.19 ((PCINT5)PB5)
unnamed: JP2.4, U4.20 ((PCINT6)PB6)
unnamed: C10.2, U4.27 (UCAP)
unnamed: C8.2, R9.2, U4.1 (XTAL1), X1.1
unnamed: C7.2, R9.1, U4.2 (XTAL(PC0)), X1.2

Notes on the sheet:
XTAL Technical Reference http://ww1.microchip.com/downloads/en/AppNotes/00826a.pdf http://www.crystek.com/documents/appnotes/Pierce-GateIntroduction.pdf
See XTAL Technical Reference Below

Parts:
C11, C14, C15: 0.1 uF; C_0603_1608Metric; MPN C0805C104K1RACAUTO
R12, R14, R15: 1K; R_0603_1608Metric; MPN CRCW08051K00JNEA
R13: 0; R_0603_1608Metric; MPN ERJ-6GEY0R00V
R16: 10K; R_0603_1608Metric; MPN CRCW080510K0JNEA
R17: 1M; R_0603_1608Metric; MPN CRCW08051M00FKEA
SW1: RESET_SWITCH; SW_SPST_PTS645; MPN EVQ-Q2U02W
U5: ATMEGA328P; TQFP-32_7x7mm_P0.8mm; MPN ATMEGA328P-PU
X2: CSTCE16MOV53-R0; Crystal_AT310_D3.0mm_L10.0mm_Horizontal_1EP_style1; MPN CSTCE16M0V53-R0

Connections:
+5V: C15.1, R16.2, U5.7 (VCC), U5.20 (AVCC); also elsewhere on the board
/ATMEGA16U2/DTR: C11.1, R12.1; also elsewhere on the board
/ATMEGA16U2/SERIAL_Rx: R14.1; also elsewhere on the board
/ATMEGA16U2/SERIAL_Tx: R15.1; also elsewhere on the board
/ATMEGA328P/328P_RESET: R13.2, R16.1, SW1.3, SW1.4, U5.1 (~RESET); also elsewhere on the board
/ATMEGA328P/ARD_AN0: U5.23 ((ADC0)PC0); also elsewhere on the board
/ATMEGA328P/ARD_AN1: U5.24 ((ADC1)PC1); also elsewhere on the board
/ATMEGA328P/ARD_AN2: U5.25 ((ADC2)PC2); also elsewhere on the board
/ATMEGA328P/ARD_AN3: U5.26 ((ADC3)PC3); also elsewhere on the board
/ATMEGA328P/ARD_AN4/SDA: U5.27 ((ADC4)PC4); also elsewhere on the board
/ATMEGA328P/ARD_AN5/SCL: U5.28 ((ADC5)PC5); also elsewhere on the board
/ATMEGA328P/ARD_DIG0: R14.2, U5.2 ((RXD)PD0); also elsewhere on the board
/ATMEGA328P/ARD_DIG1: R15.2, U5.3 ((TXD)PD1); also elsewhere on the board
/ATMEGA328P/ARD_DIG2: U5.4 ((INT0)PD2); also elsewhere on the board
/ATMEGA328P/ARD_DIG3: U5.5 ((INT1)PD3); also elsewhere on the board
/ATMEGA328P/ARD_DIG4: U5.6 ((T0)PD4); also elsewhere on the board
/ATMEGA328P/ARD_DIG5: U5.11 ((T1)PD5); also elsewhere on the board
/ATMEGA328P/ARD_DIG6: U5.12 ((AIN0)PD6); also elsewhere on the board
/ATMEGA328P/ARD_DIG7: U5.13 ((AIN1)PD7); also elsewhere on the board
/ATMEGA328P/ARD_DIG8: U5.14 ((ICP)PB0); also elsewhere on the board
/ATMEGA328P/ARD_DIG9: U5.15 ((OC1)PB1); also elsewhere on the board
/ATMEGA328P/ARD_DIG10/SPI_SS: U5.16 ((SS)PB2); also elsewhere on the board
/ATMEGA328P/ARD_DIG11/SPI_MOSI: U5.17 ((MOSI)PB3); also elsewhere on the board
/ATMEGA328P/ARD_DIG12/SPI_MISO: U5.18 ((MISO)PB4); also elsewhere on the board
/ATMEGA328P/ARD_DIG13/SPI_SCK: U5.19 ((SCK)PB5); also elsewhere on the board
/ATMEGA328P/AREF: C14.1, U5.21 (AREF); also elsewhere on the board
GND: C14.2, C15.2, R12.2, SW1.1, SW1.2, U5.8 (GND), U5.22 (AGND), X2.2 (PM); also elsewhere on the board
unnamed: C11.2, R13.1
unnamed: R17.2, U5.9 (XTAL1), X2.3
unnamed: R17.1, U5.10 (XTAL2), X2.1

Notes on the sheet:
Atmel Appnote: AVR042 - AVR Hardware Design Considerations http://www.atmel.com/Images/Atmel-2521-AVR-Hardware-Design-Considerations_ApplicationNote_AVR042.pdf Refer to this for PCB layout information

Parts:
D7: 1N4148W-7-F; D_SMA; MPN 1N4148W-7-F
XA1: Arduino_Uno_R3_SMD_Shield; Arduino_Uno_R3_MountingHole

Connections:
+3V3: XA1.3V3 (3.3V); also elsewhere on the board
+5V: D7.1 (K), XA1.5V1 (5V), XA1.IORF (IOREF); also elsewhere on the board
/ATMEGA328P/328P_RESET: XA1.RST1 (RESET), XA1.RST2 (SPI_RESET); also elsewhere on the board
/ATMEGA328P/ARD_AN0: XA1.A0; also elsewhere on the board
/ATMEGA328P/ARD_AN1: XA1.A1; also elsewhere on the board
/ATMEGA328P/ARD_AN2: XA1.A2; also elsewhere on the board
/ATMEGA328P/ARD_AN3: XA1.A3; also elsewhere on the board
/ATMEGA328P/ARD_AN4/SDA: XA1.A4, XA1.SDA; also elsewhere on the board
/ATMEGA328P/ARD_AN5/SCL: XA1.A5, XA1.SCL; also elsewhere on the board
/ATMEGA328P/ARD_DIG0: XA1.D0 (D0/RX); also elsewhere on the board
/ATMEGA328P/ARD_DIG1: XA1.D1 (D1/TX); also elsewhere on the board
/ATMEGA328P/ARD_DIG2: XA1.D2 (D2_INT0); also elsewhere on the board
/ATMEGA328P/ARD_DIG3: XA1.D3 (D3_INT1); also elsewhere on the board
/ATMEGA328P/ARD_DIG4: XA1.D4; also elsewhere on the board
/ATMEGA328P/ARD_DIG5: XA1.D5; also elsewhere on the board
/ATMEGA328P/ARD_DIG6: XA1.D6; also elsewhere on the board
/ATMEGA328P/ARD_DIG7: XA1.D7; also elsewhere on the board
/ATMEGA328P/ARD_DIG8: XA1.D8; also elsewhere on the board
/ATMEGA328P/ARD_DIG9: XA1.D9; also elsewhere on the board
/ATMEGA328P/ARD_DIG10/SPI_SS: XA1.D10 (D10_CS); also elsewhere on the board
/ATMEGA328P/ARD_DIG11/SPI_MOSI: XA1.D11, XA1.MOSI (SPI_MOSI); also elsewhere on the board
/ATMEGA328P/ARD_DIG12/SPI_MISO: XA1.D12, XA1.MISO (SPI_MISO); also elsewhere on the board
/ATMEGA328P/ARD_DIG13/SPI_SCK: XA1.D13, XA1.SCK (SPI_SCK); also elsewhere on the board
/ATMEGA328P/AREF: XA1.AREF; also elsewhere on the board
GND: XA1.GND1 (GND), XA1.GND2 (GND), XA1.GND3 (GND), XA1.GND4 (SPI_GND); also elsewhere on the board
unnamed: D7.2 (A), XA1.5V2 (SPI_5V)
VDD: XA1.VIN; also elsewhere on the board

Board: 4 copper layers, 68.6 x 53.3 mm, 54 parts (0 on the bottom side), 62 nets.

## Commit log

2023-06-07 update to kicad7
2023-06-26 add packages
2023-06-26 change power symbols and Arduino header
2023-06-26 initial PCB layout
2023-06-27 update power symbols
2023-06-27 update pcb to 4 layers
    - update PCB to 4 layers
    - add 3d models of pin sockets to Arduino board
    - update net color
    - add ground/power planes (inner layers)
